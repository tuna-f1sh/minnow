# Repository tuna-f1sh/minnow

File README.md:

# Minnow - USB-C DAM Tool

Minnow is a tool for using DAM (Debug Accessory Mode), providing an interface to SWD or JTAG and/or UART from the device. It expands upon [this concept](https://github.com/BitterAndReal/SWD-over-USB-C) to include a USB-UART and some utility for use within test rigs. It could be considered SWD over DAM with a sprinkling of [USB cereal](https://github.com/oxda/usb-cereal) - unlike usb-cereal it does not use the Chromebook UART mapping in favour of maintaining USB-C rotational symmetry.

* Enables and interfaces USB DAM configured in image below; Full SWD or JTAG over USB-C.
* Provides board designer the option of using RX+ for NRST/RXD and RX- for SWO/TXD - either single-wire trace communication (RTT) or UART.
* Four configurable GPIO on FT230 for test rig control of UUT: power enable; RX pin control; reset.
* TagConnect TC2030 and ARM 10-pin header to debugger.
* USB pass-through or FT230 USB UART to device.
* VTARGET reference from device or external.
* Maintains USB-C rotational symmetry.
* Alternate Mode 3.1+ can still be used in the main application with normal hosts.

[Original reference](https://github.com/BitterAndReal/SWD-over-USB-C/blob/main/images/SWD%20over%20USB-C%20Pinout-01.png) modified to include option of UART.

# Status and Obtaining

[The latest release](https://github.com/tuna-f1sh/minnow/releases/latest) is full tested and I have PCBAs for purchase:

* [Purchase from my shop](https://shop.jbrengineering.co.uk/product/minnow-usb-c-debug-accessory-mode-tool-dam/).
* [Purchase from Tindie](https://www.tindie.com/products/jbrengineering/minnow-usb-c-debug-accessory-mode-tool-dam/).
* Since it's a development tool, it uses 0603 so can be easily assembled/modified by hand.

# Usage

__Minnow connected to the USB DAM example test board - this would be integrated to a target in practice__

Here is a quick video showing basic usage: https://youtu.be/QQiKsJ13bL0

**Note** the target device must be designed to enable DAM mode following the USB specification and Minnow DAM USB-C connections. I have made an example board that does this, see below.

## Cable

If a cable is required between Minnow and the device (TS), the cable needs to be a **complete USB-C extension cable** with all [Alternate Mode](https://en.wikipedia.org/wiki/USB-C#Alternate_Mode) wires. USB 3.1+, DisplayPort, Thunderbolt and HDMI rated cables _should_ include these. Here are a couple: [usb-c-extension-cable-for-raspberry-pi-4](https://thepihut.com/products/usb-c-extension-cable-for-raspberry-pi-4) or [Tripp Lite U421-20N-G2](https://www.digikey.ch/en/products/detail/tripp-lite/U421-20N-G2/16161593).

USB-C extension cables are not [technically specification compliant](https://hackaday.com/2022/12/27/all-about-usb-c-illegal-adapters/) but one is required for DAM because no compliant male-male cable will supply both CC1 and CC2 between the the DTS and TS. See [USB Type-C](https://www.usb.org/sites/default/files/USB%20Type-C%20Spec%20R2.0%20-%20August%202019.pdf): B.2.3.1.

I learnt this the hard way: R1 Minnow had a receptacle for both the host and device and no cable worked to enable USB DAM using the CC pull-ups with logic AND. As the specification says, this is why a direct plug is required for USB DAM mode and why Minnow R2 now has one.

The cable to the host can be a USB 2.0.

## Example Device 

I've included an example design for the device end: './example-dev/usb-dam.kicad\_pro' [pdf](./example-dev/usb-dam.pdf). It can be used for testing and as a foundation for a project with DAM. There are clearly alternative design choices that can be made based on the requirements of the device but it is a good starting point. The layout was done in haste as a means to test the Minnow board!

Essentially the target must detect when the CC lines are pulled up with the values specified in the USB specification (500mA @5V 10kΩ on CC1 and 22kΩ on CC2). Because the CC lines might also have 5k1 pull-downs, a potential divider is created:

* CC1: Host 22kΩ pull-up to 5V and device 5.1kΩ pull-down = 0.9V
* CC2: Host 10kΩ pull-up to 5V and device 5.1kΩ pull-down = 1.7V

The example board uses two op-amps configured as non-inverting amplifiers to buffer this to a logic AND, which enables a 4-channel switch to connect the debug lines to the Alternate Mode pins.

## FAQ

### What's the default configuration? 

USB host to device; device powered; full SWD on debug headers; VCCIO from VTARGET.

### VCCIO selection

By default, VCCIO for the FT230 is supplied from VTARGET (< 10 uA current demand from logic gates) to ensure the same logic level as the target. VCCIO controls the logic level for the GPIO and UART. Cut JP5 1-2 and link 2-3 to use JP6 source - default 3V3 1-2, 2-3 VEXT for external source (1V8 for example). **If using a VCCIO source less than 3V3, one should take the LEDs out of circuit by removing R1 and R2 as they are pulled to 3V3.**

### Why aren't the UART act LEDs blinking?

Logic level is sourced from VCCIO; VTARGET from the device by default. If no device is attached, there is no logic level and so nothing to sink the LEDs or send UART for that matter. Consider this a feature not a bug since they don't blink if nothing is output/listening 🙂. To change this, VCCIO can be self-supplied with JP5 2-3 - see 'VCCIO Selection'.

### Why doesn't the FT230 USB UART work?

One must switch SW1:1 ON to enable USB -> FT230 rather than device. Also be aware that the default configuration VCCIO is supplied from the device and without this there is no logic on the UART/GPIO pins. See 'VCCIO Selection'. It's the reason I didn't include a GPIO to the device power since it would not work without an external VCCIO source.

### How can I control the device power with the FT230

First switch the VCCIO source from VTARGET - see 'VCCIO Selection' - as logic will be required without the device. Add the resistor R15 (680R or anthing to protect GPIO) to link CB3 to the load switch. It's active LOW.

### The device is powered but no DAM pins are working

The cable to the device is probably not a USB 3.1+ (or a bad one) and does not include the alternate mode pins. Use a cable tester to continuity test the cable or find a better one! See 'Cable'.

### How can I configure/use the FT230?

See [ftx-prog](https://github.com/richardeoin/ftx-prog), the main [FTDI utilities page](https://ftdichip.com/utilities/) or the [pyftdi module](https://eblot.github.io/pyftdi/tools.html). The GPIO pins can be changed at runtime or non-volatile with the EEPROM - see './power-gpio.py' as an example of toggling power to the device.

I personally use the 'ftconf.py' script as part of _pyftdi_ to provision new devices using './provision.py'.

# Useful Links

* [SWD over USB-C](https://github.com/BitterAndReal/SWD-over-USB-C)
* [USB Type-C](https://www.usb.org/sites/default/files/USB%20Type-C%20Spec%20R2.0%20-%20August%202019.pdf)
* [ARM JTAG/SWD Interface](https://developer.arm.com/documentation/101636/0100/Debug-and-Trace/JTAG-SWD-Interface)
* [FT230X datasheet](https://www.ftdichip.com/Support/Documents/DataSheets/ICs/DS_FT230X.pdf)

## KiCad design dam_connect/dam_connect/dam_connect.kicad_pcb

Parts:
FID1, FID2: Fiducial; Fiducial_0.5mm_Mask1mm
J1: Conn_ARM_JTAG_SWD_20; IDC-Header_2x10_P2.54mm_Horizontal
J2: Conn_ARM_JTAG_SWD_10; IDC-Header_2x05_P2.54mm_Horizontal
JP1, JP2: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm_NumberL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

Connections:
+5V: J1.19 (DBGACK/NC), JP1.3 (B)
/RTCLK: J1.11 (RTCK), J2.7 (NC/RCLK)
/SWCLK: J1.9 (TCK/SWCLK), J2.4 (SWCLK/TCK)
/SWDIO: J1.7 (TMS/SWDIO), J2.2 (SWDIO/TMS)
/SWO: J1.13 (TDO/SWO), J2.6 (SWO/TDO)
/TDI: J1.5 (TDI), J2.8 (NC/TDI)
/~RESET: J1.15 (~SRST), J2.10 (~RESET)
/~nTRST: J1.3 (~TRST), JP2.3 (B)
GND: J1.4 (GND), J1.6 (GND), J1.8 (GND), J1.10 (GND), J1.12 (GND), J1.14 (GND), J1.16 (GND), J1.18 (GND), J1.20 (GND), J2.3 (GND), JP1.1 (A), JP2.2 (C)
unnamed: J2.9 (GNDDetect), JP2.1 (A)
unnamed: J2.5 (GND), JP1.2 (C)
VCC: J1.1 (VTREF), J2.1 (VTref)

Board: 2 copper layers, 42.4 x 34.1 mm, 6 parts (0 on the bottom side), 12 nets.

## KiCad design DAMLink.kicad_pcb

Board: 2 copper layers, 41.0 x 33.0 mm, 74 parts (23 on the bottom side), 49 nets, no tracks yet.

Parts:
C1: 10nF; C_0603_1608Metric
C2, C3, C5: 100nF; C_0603_1608Metric
C4: 1uF; C_0603_1608Metric
D1: TXD; LED_0603_1608Metric
D2: RXD; LED_0603_1608Metric
D3: WHITE; LED_0603_1608Metric
FB1: 120R/0.55A; L_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.7mm_M2.5_ISO7380_Pad
J1: PicoBlade; Molex_PicoBlade_53048-0610_1x06_P1.25mm_Horizontal
J2: USB_C_Receptacle_Host; USB_C_Receptacle_Amphenol_12401610E4-2A
J3: PicoBlade; PinHeader_1x04_P1.27mm_Vertical
J4: VCCIO_EXT; PinHeader_1x02_P1.27mm_Vertical
J5: TC2050-IDC; Tag-Connect_TC2050-IDC-FP_2x05_P1.27mm_Vertical
J6: Conn_ST_STDC14; CON14_2X7_DUK_FTSH_SAI
JP1, JP6, JP7, JP8, JP9: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP2, JP2#2, JP3, JP3#2, JP5: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
P1: USB_C_Plug; USB_C_Plug_Molex_105444
R1, R2: 5k1; R_0603_1608Metric
R3, R4, R11: 22k; R_0603_1608Metric
R5, R6, R12: 1k; R_0603_1608Metric
R7, R8, R9, R10: 680R; R_0603_1608Metric
R13: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04A_W5.08mm_P1.27mm_JPin
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP13#2, TP14, TP14#2, TP15, TP15#2, TP16, TP16#2, TP17, TP17#2: TestPoint_Small; TestPoint_Pad_D1.0mm
U1: FT230XQ; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm
U2: USB3740B-AI2; UQFN-10_1.3x1.8mm_P0.4mm
U3: TMUX1574RSVR; RSV16_TEX
U4, U6: USBLC6-4SC6; SOT-23-6
U5: SiP32432DR3; SOT-363_SC-70-6

Connections:
+3V3: C3.1, D1.2 (A), D2.2 (A), JP3.1 (A), JP3#2.1 (A), U1.8 (3V3OUT), U1.9 (~RESET)
/DEV_CC1: P1.A5 (CC), R13.2
/DEV_CC2: P1.B5 (VCONN), R14.2
/DEV_D+: P1.A6 (D+), TP11.1, U2.2 (DP_1), U6.3 (I/O2)
/DEV_D-: P1.A7 (D-), TP12.1, U2.1 (DM_1), U6.1 (I/O1)
/DEV_RX+: P1.A11 (RX2+), P1.B11 (RX1+), U3.10 (D4), U4.3 (I/O2)
/DEV_RX-: P1.A10 (RX2-), P1.B10 (RX1-), U3.7 (D3), U4.1 (I/O1)
/DEV_RXD: J1.4, J3.3, JP6.1 (A), JP9.2 (B), U3.8 (S3B)
/DEV_TX+: P1.A2 (TX1+), P1.B2 (TX2+), U3.5 (D2), U6.6 (I/O4)
/DEV_TX-: P1.A3 (TX1-), P1.B3 (TX2-), U3.2 (D1), U6.4 (I/O3)
/DEV_TXD: J1.5, J3.2, JP7.1 (A), JP8.2 (B), U3.11 (S4B)
/HOST_CC1: J2.A5 (CC1), R2.1
/HOST_CC2: J2.B5 (CC2), R1.1
/HOST_D+: J2.A6 (D+), J2.B6 (D+), TP1.1, U2.10 (DP)
/HOST_D-: J2.A7 (D-), J2.B7 (D-), TP2.1, U2.9 (DM)
/IO0: J1.2, U3.1 (S1B)
/IO1: J1.3, U3.4 (S2B)
/RXLED/CB2: R6.2, R9.1, SW1.4, TP7.1, U1.5 (CBUS2)
/SLEEP/CB3: R10.1, TP8.1, U1.14 (CBUS3)
/SWCLK: J5.4, J6.6 (JCLK/SWCLK), TP14.1, TP14#2.1, U3.16 (S1A)
/SWDIO: J5.2, J6.4 (JTMS/SWDIO), TP13.1, TP13#2.1, U3.3 (S2A)
/SWO: J5.6, J6.8 (JTDO/SWO), TP17.1, TP17#2.1, U3.12 (S4A)
/SWT_RX+: R7.2, SW1.6, U3.15 (SEL)
/SWT_RX-: R8.2, SW1.7, U3.13 (~EN)
/TXDEN/CB0: R7.1, TP5.1, U1.12 (CBUS0)
/TXLED/CB1: R5.2, R8.1, TP6.1, U1.11 (CBUS1)
/UART_D+: TP9.1, U1.6 (USBDP), U2.6 (DP_2)
/UART_D-: TP10.1, U1.7 (USBDM), U2.7 (DM_2)
/UART_USB: R4.1, SW1.8, TP4.1, U2.4 (S)
/VBUS_DEV: D3.2 (A), JP4.2 (B), P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), U5.1 (OUT)
/VREF: J5.1, J6.3 (VCC), JP5.2 (C), TP15.1, TP15#2.1
/VTARGET: JP2.1 (A), JP2#2.1 (A), JP5.1 (A), P1.A8 (SBU1), P1.B8 (SBU2), U4.4 (I/O3), U4.6 (I/O4)
/~DEV_ON: R10.2, R11.1, U5.3 (~ON)
/~PASS_USB: R3.1, R9.2, TP3.1, U2.3 (OE_N)
/~RESET: J5.10, J6.12 (~RST), SW1.5, TP16.1, TP16#2.1, U3.9 (S3A)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, H1.1, H2.1, H3.1, H4.1, J1.6, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.4, J4.2, J5.3, J5.5, J6.5 (GND), J6.7 (GND), J6.11 (GNDDetect), P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R1.2, R2.2, R3.2, R4.2, R11.2, R12.2, U1.3 (GND), U1.13 (GND), U1.17 (GND), U2.8 (GND), U3.6 (GND), U4.2 (GND), U5.2 (GND), U5.5 (GND), U6.2 (GND)
unnamed: C1.1, FB1.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D3.1 (K), R12.1
unnamed: J4.1, JP3.3 (B), JP3#2.3 (B)
unnamed: J6.13 (VCP_RX), JP6.2 (B)
unnamed: J6.14 (VCP_TX), JP7.2 (B)
unnamed: JP1.1 (A), U1.10 (VCC)
unnamed: JP2.3 (B), JP2#2.3 (B), JP3.2 (C), JP3#2.2 (C)
unnamed: JP8.1 (A), U1.15 (TXD)
unnamed: JP9.1 (A), U1.2 (RXD)
VBUS: C2.1, C4.1, FB1.2, JP1.2 (B), JP4.1 (A), R13.1, R14.1, SW1.1, U2.5 (VDD), U4.5 (VBUS), U5.4 (IN), U6.5 (VBUS)
VCC: C5.1, J1.1, J3.1, JP2.2 (C), JP2#2.2 (C), JP5.3 (B), SW1.2, SW1.3, U1.1 (VCCIO), U3.14 (VDD)

## KiCad design example-dev/usb-dam.kicad_pcb

Board: 2 copper layers, 39.0 x 25.0 mm, 41 parts (1 on the bottom side), 29 nets.

Parts:
C1, C2: 10nF; C_0603_1608Metric
C3: 1uF; C_0603_1608Metric
C4, C5, C6, C7: 100nF; C_0603_1608Metric
D1: PRTR5V0U2X; SOT-143
FB1, FB2, FB3: 120R/0.55A; L_0603_1608Metric
J1: USB_C_Receptacle; USB_C_Receptacle_Amphenol_12401610E4-2A
J2: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
JP3: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R8, R11: 10K; R_0603_1608Metric
R2, R3, R9, R10: 5k1; R_0603_1608Metric
R4, R12: 22k; R_0603_1608Metric
R5, R6, R7: 680R; R_0603_1608Metric
TP1, TP6: TestPoint; TestPoint_Pad_D2.0mm
TP2, TP3, TP4, TP5, TP7, TP8, TP12, TP13: TestPoint; TestPoint_Pad_D1.0mm_Tight
U1: MCP6002-xMC; DFN-8-1EP_3x2mm_P0.5mm_EP1.75x1.45mm
U2: SiP32431DR3; SOT-363_SC-70-6
U3: TMUX1574RSVR; IC_TMUX1574RSVR
U4: 74LVC1G08; UFDFN-6_1.45x1mm

Connections:
/CC1: R5.2, TP12.1, U1.3 (+)
/CC1_AMP: R8.1, U1.1, U4.1
/CC2: R7.2, TP13.1, U1.5 (+)
/CC2_AMP: R11.1, U1.7, U4.2
/DAM_EN: R4.1, R6.2, TP2.1, U2.3 (ON), U3.15 (SEL), U4.4
/RX+: J1.A11 (RX2+), J1.B11 (RX1+), TP8.1, U3.8 (S3B)
/RX-: J1.A10 (RX2-), J1.B10 (RX1-), TP7.1, U3.11 (S4B)
/SBU: J1.A8 (SBU1), J1.B8 (SBU2), JP3.2 (C)
/SHIELD: C1.1, FB1.1, J1.S1 (SHIELD), R1.1
/SWCLK: J2.4, U3.5 (D2)
/SWDIO: J2.3, U3.2 (D1)
/SWO/TXD: J2.5, U3.7 (D3)
/TX+: J1.A2 (TX1+), J1.B2 (TX2+), TP4.1, U3.1 (S1B)
/TX-: J1.A3 (TX1-), J1.B3 (TX2-), TP3.1, U3.4 (S2B)
/USB_D+: D1.2 (I/O1), J1.A6 (D+), J1.B6 (D+), TP6.1
/USB_D-: D1.3 (I/O2), J1.A7 (D-), J1.B7 (D-), TP1.1
/USB_GND: FB3.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND)
/VBUS_CONN: C2.1, C3.1, C5.1, FB2.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
/VTARGET: JP3.1 (A), JP4.2 (B), U2.1 (OUT)
/~EN: J2.7, R12.1, U3.13 (~EN)
/~NRST/RXD: J2.6, U3.10 (D4)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, D1.1 (GND), FB1.2, FB3.2, J2.8, R1.2, R2.2, R3.2, R4.2, R9.2, R10.2, R12.2, U1.4 (V-), U1.9 (V-), U2.2 (GND), U2.5 (GND), U3.6 (GND), U4.3 (GND)
unnamed: J1.A5 (CC1), R2.1, R5.1
unnamed: J1.B5 (CC2), R3.1, R7.1
unnamed: JP3.3 (B), R6.1
unnamed: R8.2, R9.1, U1.2 (-)
unnamed: R10.1, R11.2, U1.6 (-)
VBUS: C4.1, D1.4 (VCC), FB2.2, J2.1, TP5.1
VCC: C6.1, C7.1, J2.2, JP4.1 (A), U1.8 (V+), U2.4 (IN), U3.14 (VDD), U4.6 (VCC)

## KiCad design minnow.kicad_pcb

Board: 2 copper layers, 41.0 x 33.0 mm, 68 parts (24 on the bottom side), 43 nets.

Parts:
C1, C3, C5, C6: 100nF; C_0603_1608Metric
C2: 10nF; C_0603_1608Metric
C4: 1uF; C_0603_1608Metric
D1: TXD; LED_0603_1608Metric
D2: RXD; LED_0603_1608Metric
D4: WHITE; LED_0603_1608Metric
FB1: 120R/0.55A; L_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.7mm_M2.5_ISO7380_Pad
J1: USB_C_Receptacle_Host; USB_C_Receptacle_Amphenol_12401610E4-2A
J3: ARM_JTAG_SWD_10_Male; 20021521-00010T1LF
J4: VCCIO_EXT; PinHeader_1x02_P1.27mm_Vertical
J5: PicoBlade; PinHeader_1x04_P1.27mm_Vertical
JP1, JP2, JP7: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
JP3, JP5, JP6: SolderJumper_3_Bridged12; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
P1: USB_C_Plug; USB_C_Plug_Molex_105444
R1, R2, R16: 1k; R_0603_1608Metric
R3, R4, R5, R6, R14: 22k; R_0603_1608Metric
R7, R8, R9, R15: 680R; R_0603_1608Metric
R10: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 5k1; R_0603_1608Metric
SW1: SW_DIP_x04; SW_DIP_SPSTx04_Slide_Copal_CHS-04A_W5.08mm_P1.27mm_JPin
SWD1: TC2030; Tag-Connect_TC2030-IDC-FP_2x03_P1.27mm_Vertical
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19: TestPoint_Small; TestPoint_Pad_D1.0mm_Tight
U1: FT230XQ; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm
U2, U3: PI5A3157CEX; SOT-363_SC-70-6
U4: USB3740B-AI2; UQFN-10_1.3x1.8mm_P0.4mm
U5: SiP32432DR3; SOT-363_SC-70-6

Connections:
+3V3: C1.1, D1.2 (A), D2.2 (A), JP6.1 (A), U1.8 (3V3OUT), U1.9 (~RESET)
/DEV_CC1: P1.A5 (CC), R10.2
/DEV_CC2: P1.B5 (VCONN), R11.2
/DEV_D+: P1.A6 (D+), TP15.1, U4.2 (DP_1)
/DEV_D-: P1.A7 (D-), TP16.1, U4.1 (DM_1)
/DEV_RX+: P1.A11 (RX2+), P1.B11 (RX1+), TP17.1, U3.4
/DEV_RX-: P1.A10 (RX2-), P1.B10 (RX1-), TP18.1, U2.4
/DEV_RXD: J5.3, JP1.1 (A), U1.2 (RXD)
/DEV_TXD: J5.2, JP2.1 (A), U1.15 (TXD)
/HOST_CC1: J1.A5 (CC1), R13.1
/HOST_CC2: J1.B5 (CC2), R12.1
/HOST_D+: J1.A6 (D+), J1.B6 (D+), TP11.1, U4.10 (DP)
/HOST_D-: J1.A7 (D-), J1.B7 (D-), TP12.1, U4.9 (DM)
/RXLED/CB2: R2.2, R9.1, SW1.4, TP5.1, U1.5 (CBUS2)
/SLEEP/CB3: R15.1, TP6.1, U1.14 (CBUS3)
/SWCLK: J3.4 (SWDCLK/TCK), P1.A3 (TX1-), P1.B3 (TX2-), SWD1.4, TP2.1
/SWDIO: J3.2 (SWDIO/TMS), P1.A2 (TX1+), P1.B2 (TX2+), SWD1.2, TP9.1
/SWO: J3.6 (SWO/TDO), SWD1.6, TP1.1, U3.3
/SWT_RX+: R5.1, R7.2, SW1.6, U3.6
/SWT_RX-: R6.1, R8.2, SW1.7, U2.6
/TXDEN/CB0: R7.1, TP3.1, U1.12 (CBUS0)
/TXLED/CB1: R1.2, R8.1, TP4.1, U1.11 (CBUS1)
/UART_D+: TP13.1, U1.6 (USBDP), U4.6 (DP_2)
/UART_D-: TP14.1, U1.7 (USBDM), U4.7 (DM_2)
/UART_USB: R3.1, SW1.8, TP8.1, U4.4 (S)
/VBUS_DEV: D4.2 (A), JP4.2 (B), P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), U5.1 (OUT)
/VREF: J3.1 (VTref), JP3.2 (C), SWD1.1, TP19.1
/VTARGET: JP3.1 (A), JP5.1 (A), P1.A8 (SBU1), P1.B8 (SBU2)
/~DEV_ON: R14.1, R15.2, U5.3 (~ON)
/~PASS_USB: R4.1, R9.2, TP7.1, U4.3 (OE_N)
/~RESET: J3.10 (~RESET), SW1.5, SWD1.3, TP10.1, U2.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, H1.1, H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.3 (GND), J3.5 (GND), J3.9 (GNDDetect), J4.2, J5.4, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), P1.S1 (SHIELD), R3.2, R4.2, R5.2, R6.2, R12.2, R13.2, R14.2, R16.2, SWD1.5, U1.3 (GND), U1.13 (GND), U1.17 (GND), U2.2 (GND), U3.2 (GND), U4.8 (GND), U5.2 (GND), U5.5 (GND)
unnamed: C2.1, FB1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: D4.1 (K), R16.1
unnamed: J4.1, JP6.3 (B)
unnamed: JP1.2 (B), U2.1
unnamed: JP2.2 (B), U3.1
unnamed: JP5.3 (B), JP6.2 (C)
unnamed: JP7.1 (A), U1.10 (VCC)
VBUS: C3.1, C4.1, FB1.2, JP4.1 (A), JP7.2 (B), R10.1, R11.1, SW1.1, U4.5 (VDD), U5.4 (IN)
VCC: C5.1, C6.1, J5.1, JP3.3 (B), JP5.2 (C), SW1.2, SW1.3, U1.1 (VCCIO), U2.5 (V+), U3.5 (V+)

## Commit log (part)

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2023-05-17 minnow layout; example-dev wip
2023-05-18 layout example board
2023-05-19 example board for production
2023-05-19 README started
2023-05-20 media files
2023-05-21 current status in readme; build action
2023-06-14 update README for R1 delivery
2023-06-14 pyftdi note and config
2023-06-17 provisioning script
2023-06-17 ft230x datasheet in README
2023-06-22 plug not receptacle for device (TS)
2023-06-23 pcb render
    active layers
2023-06-23 diamensions in user drawing
2023-07-04 lock usb-c plug
2023-07-25 fix example AND footprint VCC 5->6
2023-07-26 eeprom crc error so just use flags
2023-07-26 README update with store links
2023-07-30 README usage video
2023-07-31 add a white LED for VBUS_DEV
2023-07-31 explain the example board a bit more
2024-01-26 remote old names in CI
2024-06-13 Update Files
    Update Files to KiCad 8.0
2024-06-13 Update minnow.kicad_sch
    Add ESD diodes on output plug
2024-06-13 Renamed Files
    Renamed files to the new project
2024-06-13 Update .gitignore
    Add "*.log" so they will not be uploaded.
2024-06-13 Add new analog switch
    Add new analog switch which has more ports to switch between SWD interface and a debug interface.
2024-06-14 Update DAMLink.kicad_sch
    Removed FTDI Chip, add stlink connector which uses vcp_usart
2024-06-14 Update DAMLink.kicad_sch
    working on schematics
2024-06-14 Update example
    Update example project to KiCad 8
2024-06-15 Update DAMLink.kicad_sch
    Changed sheet size to A2
    Add FTDI chip back on, since it has some nice features
2024-06-15 Update .gitignore
    Add two file types to .gitignore
2024-06-15 Add libraries
    Add TC2050 Debug Probe
    Add TMUX1574RSVR analog switch
2024-06-15 Update DAMLink.kicad_sch
    Add TC2050 Debug probe (with clips)
2024-06-15 Add new stuff
    Add TMUX1574 MUX
    Add TC2050 Footprint
    Add STDC14 Footprint
    Removed PI5A3157 MUX
    Now full swd port can be switched with test port
2024-06-15 Add new footprint
2024-06-15 Remove wrong libraries
    Remove "altium" libraries which where downloaded wrong from SnapEDA.
    Import correct libraries from Manufracturer and from UltranLibrary
    Clear whole PCB.
2024-06-15 Update DAMLink.kicad_pcb
    Remove Logo from
    Add information in header
2024-06-15 Add small connector adapter
    Add an adapter from ARM20 to ARM10 Connector interface to connect TC2050 debugging probe to ST-Link V3 Set.
2024-06-15 Finished connector PCB
2025-02-20 r3 to pcbway
2025-02-21 migrate to KiCad 9.0
2025-03-24 provision script up to date
2026-03-11 add supplier jlcpcb and lcsc codes
